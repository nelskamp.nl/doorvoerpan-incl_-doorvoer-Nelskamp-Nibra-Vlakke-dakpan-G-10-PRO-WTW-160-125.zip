Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 296c48ef-986d-4195-a223-c4e01234480f.ifc
Time: 2025-01-21T09:36:57
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcFlowTerminal, doorvoerpan incl. doorvoer Nelskamp - Nibra Vlakke dakpan G-10 PRO WTW 160-125
In: Bouwlaag
Material: terracotta
Pset_Data - WUID: AgAAANydL9sEAAAAkNICAAVc6AAAj6cAADxtAQC41gIAZtMCAAIAAQUBAQAAAAEAAACDAAEBAAAAAgAAAAAAAACvXNpzbJfcQ5RoBTXbV_yIBVaQAACGUgAAIdcAAIjVAgCe1wIAAACXBgEABWYEAACs7QAAPG0BAA2lAAAKBAAAAQAQAAEBAAAAAwAAALk8AAAF9rYAAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAANydL9sEAAAAkNICAAVc6AAAj6cAADxtAQC41gIAZtMCAAIAAQUBAQAAAAEAAACDAAEBAAAAAgAAAAAAAACvXNpzbJfcQ5RoBTXbV_yIBVaQAACGUgAAIdcAAIjVAgCe1wIAAACXBgEABWYEAACs7QAAPG0BAA2lAAAKBAAAAQAQAAEBAAAAAwAAALk8AAAF9rYAAGQwAADGpwAAo60AAOnYAAAAAA)); merk: Nelskamp; type: WTW 160-125; kenmerkende grondstof: terracotta; serie: Nibra Vlakke dakpan G-10 PRO; tussenpan: keramische tussenpan Nelskamp - Nibra Vlakke dakpan G-10 PRO natuurrood (601); doorvoerelement: dakpandoorvoer WTW 160-125 Nelskamp - WTW 160-125
